;CALCULADORA
start:
   LDI R26,0
   LDI R27,0
   LD R16,X+						;CÓDIGO 0: SUMA			;INGRESAR OPERANDOS EN LOS REGISTROS R0 Y R1
   LD R17,X+						;CÓDIGO 1: RESTA		;INGRESAR CÓDIGO DE OPERACIÓN EN EL REGISTRO R2
   LD R18,X+						;CÓDIGO 2: AND			;RESULTADO FINAL SE ALMACENA EN EL REGISTRO R3
   CPI R18,0						;CÓDIGO 3: OR
   BRNE PASO1						;CÓDIGO 4: XOR
   MOV R19,R16						;CÓDIGO 5: NOT
   ADD R19,R17
   ST X,R19
   PASO1:	
   CPI R18,1
   BRNE PASO2
   MOV R19,R16
   SUB R19,R17
   ST X,R19
   PASO2:
   CPI R18,2
   BRNE PASO3
   MOV R19,R16
   AND R19,R17
   ST X,R19
   PASO3:
   CPI R18,3
   BRNE PASO4
   MOV R19,R16
   OR R19,R17
   ST X,R19
   PASO4:
   CPI R18,4
   BRNE PASO5
   MOV R19,R16
   EOR R19,R17
   ST X,R19
   PASO5:
   CPI R18,5
   BRNE EXIT
   MOV R19,R16
   COM R19
   ST X,R19
   EXIT:
   JMP start



